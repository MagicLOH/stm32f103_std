# Keil uVision project template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103_MD,USE_STDPERIPH_DRIVER
  c include: ..\driver;..\driver\CMSIS\inc;..\driver\STM32F10x_StdPeriph_Driver\inc;..\driver\system\inc;..\bsp\led/inc;..\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group driver/CMSIS
    ../Driver/CMSIS/Src/: system_stm32f10x.c
    ../Driver/CMSIS/Src/arm/: startup_stm32f10x_md.s
  group driver/STM32F10x_StdPeriph_Driver
    ../driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group driver/system
    ../Driver/System/Src/: delay.c sys.c usart.c
  group bsp/led
    ../bsp/led/src/: led.c
  group user
    ../User/Src/: main.c stm32_it.c
    ../User/Inc/: stm32f10x_conf.h
